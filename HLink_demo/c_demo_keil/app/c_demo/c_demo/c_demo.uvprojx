# Keil uVision project c_demo.uvprojx, settings and files
target c_demo (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: c_demo +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin -o .\Target_flash_eeprom.bin .\Objects\*.axf
  AfterMake: ../../bin_add_info.exe
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CORTEX_M3,ARM_MATH_CM3,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\..\..\cmsis\CMSIS\Include;..\..\..\lib\adt3102_hardwarelib\adt3102_gpio;..\..\lib\adt3102_comlib;..\..\..\lib\adt3102_hardwarelib\adt3102_i2c;..\..\..\lib\adt3102_hardwarelib\adt3102_adc;..\..\..\lib\adt3102_hardwarelib\adt3102_dma;..\..\..\lib\adt3102_hardwarelib\adt3102_timer;..\..\..\lib\adt3102_hardwarelib\adt3102_tx;..\..\..\lib\adt3102_hardwarelib\adt3102_system;..\..\..\cmsis\CMSIS\Include;..\..\..\lib\adt3102_comlib;..\..\..\lib\adt3102_hardwarelib\adt3102_uart;..\..\..\lib\adt3102_hardwarelib\adt3102_rx;..\..\..\lib\adt3102_hardwarelib\adt3102_pmu;..\..\..\lib\adt3102_hardwarelib\adt3102_timer;..\src;..\src\adt3102_inthandler;..\src;..\src\arm_fft;..\..\..\lib\adt3102_hardwarelib\adt3102_tinyframe
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group startup
    ../../../lib/adt3102_comlib/: arm_bitreversal2.S
    ../../../cmsis/Device/ARM/CMSDK_CM3/Source/ARM/: startup_CMSDK_CM3.s
  group application
    ../src/: main.c adt3102_init.c
    ../src/adt3102_inthandler/: adt3102_inthandler.c
  group adt3102_lib
    ../../../lib/adt3102_hardwarelib/adt3102_gpio/: adt3102_gpio.c
    ../../../lib/adt3102_hardwarelib/adt3102_timer/: adt3102_timer.c
    ../../../lib/adt3102_hardwarelib/adt3102_uart/: adt3102_uart.c
    ../../../lib/adt3102_hardwarelib/adt3102_tinyframe/: TinyFrame.c
    ../../../lib/adt3102_hardwarelib/adt3102_system/: adt3102_system.c
    ../../../lib/adt3102_hardwarelib/adt3102_pmu/: adt3102_pmu.c
    ../../../lib/adt3102_hardwarelib/adt3102_rx/: adt3102_rx.c
    ../../../lib/adt3102_hardwarelib/adt3102_tx/: adt3102_tx.c
